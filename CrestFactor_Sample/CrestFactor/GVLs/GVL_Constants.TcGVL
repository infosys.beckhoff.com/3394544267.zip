VAR_GLOBAL CONSTANT
	cOversamples 		: UDINT 	:= 10;		// number of oversamples
	cChannels			: UDINT		:= 2;		// number of channles
	cBufferLength		: UDINT		:= 2000;	// length of input buffer	
END_VAR
